# Keil uVision project PSV4R3A-4C.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: PSV4R3A-4C +hex
  c flags: Optimize=8 SizeSpeed=1
  group Sources
    ./: pll.c main.c rtx.c hw.c cmd.c adc.c utily.c pwm.c
  group Headers
    ./: stc8.h pll.h hw.h adc.h utily.h rtx.h cmd.h
